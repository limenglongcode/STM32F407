# Keil uVision project pro.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_spi.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group USER
    ./: main.c stm32f4xx_it.c
  group APP
    ./APP/: delay.c key.c config.h delay.h iic.c iic.h uart.c uart.h key.h
    ../: README.md
